<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
  </group>
  <group>
    <name>CMIS</name>
    <file>
      <name>$PROJ_DIR$\CMSIS\stm32f4xx.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\stm32f4xx_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\system_stm32f4xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\system_stm32f4xx.h</name>
    </file>
  </group>
  <group>
    <name>Driver</name>
    <file>
      <name>$PROJ_DIR$\Driver\src\bsp_tft_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Driver\src\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Driver\src\gpio.c</name>
    </file>
  </group>
  <group>
    <name>Fonts</name>
    <file>
      <name>$PROJ_DIR$\User\fonts\asc12.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\User\fonts\asc16.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\User\fonts\hz12.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\User\fonts\hz16.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\User\fonts\hz24.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\User\fonts\hz32.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\User\fonts\ra8875_asc_width.c</name>
    </file>
  </group>
  <group>
    <name>Library</name>
    <file>
      <name>$PROJ_DIR$\Library\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Library\src\stm32f4xx_dcmi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Library\src\stm32f4xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Library\src\stm32f4xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Library\src\stm32f4xx_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Library\src\stm32f4xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Library\src\stm32f4xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Library\src\stm32f4xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Library\src\stm32f4xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Library\src\stm32f4xx_usart.c</name>
    </file>
  </group>
  <group>
    <name>Startup</name>
    <file>
      <name>$PROJ_DIR$\Startup\startup_stm32f40xx.s</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\User\main.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\ReadMe.txt</name>
  </file>
</project>


