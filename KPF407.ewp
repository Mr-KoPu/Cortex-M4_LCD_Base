# IAR project KPF407.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZE ST STM32F407ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F40XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: App; CMSIS; Driver\inc; Library\inc; User; User\fonts; FatFS\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: ReadMe.txt
  group App
    Driver/src/: ra8875_flash.c
  group CMIS
    CMSIS/: stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group Driver
    Driver/src/: bsp.c bsp_spi_flash.c bsp_timer.c delay.c gpio.c
  group Driver/TFT_LCD
    Driver/src/: bsp_ra8875_flash.c bsp_ra8875_port.c bsp_tft_lcd.c bsp_touch.c LCD_RA8875.c LCD_SPFD5420.c
  group FatFS
    FatFS/src/option/: cc936.c
    FatFS/src/: diskio.c ff.c
  group Fonts
    User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c
  group Library
    Library/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Startup
    Startup/: startup_stm32f40xx.s
  group User
    User/: bmp.c common.h main.c param.c
