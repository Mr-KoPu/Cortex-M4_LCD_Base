# IAR project Backup of KPF407.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZE ST STM32F407ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F40XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: CMSIS; Library\inc; User; Driver\inc; User\fonts
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: ReadMe.txt
  group CMIS
    CMSIS/: stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group Driver
    Driver/src/: bsp_tft_lcd.c delay.c gpio.c
  group Fonts
    User/fonts/: asc12.c asc16.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group Library
    Library/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Startup
    Startup/: startup_stm32f40xx.s
  group User
    User/: main.c
